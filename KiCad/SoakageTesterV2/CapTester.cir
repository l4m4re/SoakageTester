* /home/arend/Documenten/KiCad/CapTester/CapTester.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: ma 08 mei 2017 15:54:02 CEST

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
* Sheet Name: /Current Sensor/
IC1  /BeaglePS/V_ref GND_BGL +5V_BGL /Current Sensor/I_sense GND_PWR ? ina213
R_shunt1  /Current Sensor/I_sense GND_PWR 10m
IC2  /BeaglePS/V_ref GND_BGL +5V_BGL Net-_IC2-Pad4_ Net-_IC2-Pad5_ ? ina213
R4  Net-_IC2-Pad4_ /Current Sensor/I_sense 180k
R3  Net-_IC2-Pad5_ GND_PWR 180k
* Sheet Name: /Power Electronics/
Q7  Net-_D1-Pad2_ Net-_D2-Pad2_ +300V_PWR IXTP10P50P
Q6  /Power Electronics/Discharge Net-_J3-Pad2_ GND_PWR IRFB3307
Q3  GND_PWR Net-_Q1-Pad2_ Net-_D1-Pad2_ MPSA42
Q1  GND_PWR Net-_Q1-Pad2_ Net-_Q1-Pad2_ MPSA42
R5  /Power Electronics/Charge Net-_Q1-Pad2_ 680
R8  +300V_PWR Net-_D1-Pad2_ 22k
D1  +300V_PWR Net-_D1-Pad2_ 12V
J1  Net-_J1-Pad1_ Net-_D4-Pad2_ Coil
J2  Net-_D4-Pad1_ /Current Sensor/I_sense Test Cap
D2  +300V_PWR Net-_D2-Pad2_ 1N4007
D3  Net-_D2-Pad2_ GND_PWR 1N4007
J3  Net-_D4-Pad1_ Net-_J3-Pad2_ Load
R10  /Power Electronics/Discharge GND_PWR 10k
Q4  GND_PWR Net-_Q1-Pad2_ Net-_D1-Pad2_ MPSA42
Q2  GND_PWR Net-_Q1-Pad2_ Net-_Q1-Pad2_ MPSA42
R6  /Power Electronics/Charge Net-_Q1-Pad2_ 680
R9  +300V_PWR Net-_D1-Pad2_ 22k
JP3  Net-_D2-Pad2_ Net-_J1-Pad1_ GND_PWR Jumper_NC_Dual
D4  Net-_D4-Pad1_ Net-_D4-Pad2_ 1N4007
JP4  Net-_JP2-Pad2_ Net-_D4-Pad2_ Net-_D4-Pad1_ Jumper_NC_Dual
Q5  Net-_JP1-Pad3_ Net-_JP2-Pad1_ -12V_PWR IRFB3307
R7  Net-_JP1-Pad3_ -12V_PWR 10k
JP1  Net-_JP1-Pad1_ ? Net-_JP1-Pad3_ Jumper_NC_Dual
Q8  Net-_JP2-Pad3_ Net-_JP1-Pad1_ Net-_Q8-Pad3_ BC337-40
Q9  Net-_Q8-Pad3_ Net-_JP2-Pad3_ -12V_PWR BUX85
R11  Net-_Q8-Pad3_ -12V_PWR 1k
JP2  Net-_JP2-Pad1_ Net-_JP2-Pad2_ Net-_JP2-Pad3_ Jumper_NC_Dual
* Sheet Name: /BeaglePS/
U1  /BeaglePS/V_ref /BeaglePS/V_ref Net-_C1-Pad2_ OPAMP_Vss GND_BGL LM2902N
R1  OPAMP_Vss Net-_C1-Pad2_ 47k
R2  Net-_C1-Pad2_ GND_BGL 47k
C1  OPAMP_Vss Net-_C1-Pad2_ 10n
C2  Net-_C1-Pad2_ GND_BGL 10n
* Sheet Name: /Beagle_IO/
* Sheet Name: /ChargeOpto/
U2  +5V_BGL Net-_R13-Pad1_ ? /Power Electronics/Charge +12V_PWR Net-_R14-Pad1_ 4N25
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ GND_BGL BC337-40
R13  Net-_R13-Pad1_ Net-_Q10-Pad1_ 470
R12  Net-_Q10-Pad2_ ? 3k3
R14  Net-_R14-Pad1_ GND_PWR 1M
* Sheet Name: /DischargeOpto/
U3  +5V_BGL Net-_R16-Pad1_ ? /Power Electronics/Discharge +12V_PWR Net-_R17-Pad1_ 4N25
Q11  Net-_Q11-Pad1_ Net-_Q11-Pad2_ GND_BGL BC337-40
R16  Net-_R16-Pad1_ Net-_Q11-Pad1_ 470
R15  Net-_Q11-Pad2_ ? 3k3
R17  Net-_R17-Pad1_ GND_PWR 1M
* Sheet Name: /BediniOpto/
U4  +5V_BGL Net-_R19-Pad1_ ? ? GND_PWR Net-_R20-Pad1_ 4N25
Q12  Net-_Q12-Pad1_ Net-_Q12-Pad2_ GND_BGL BC337-40
R19  Net-_R19-Pad1_ Net-_Q12-Pad1_ 470
R18  Net-_Q12-Pad2_ ? 3k3
R20  Net-_R20-Pad1_ -12V_PWR 1M

.end
